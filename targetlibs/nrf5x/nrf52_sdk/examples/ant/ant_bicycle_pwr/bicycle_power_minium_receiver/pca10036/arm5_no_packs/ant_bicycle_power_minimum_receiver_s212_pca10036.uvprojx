# Keil uVision project ant_bicycle_power_minimum_receiver_s212_pca10036.uvprojx, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1
  c define: ANT_STACK_SUPPORT_REQD TRACE_UART TRACE_CALIBRATION TRACE_DATA_PAGE S212 BOARD_PCA10036 CONFIG_GPIO_AS_PINRESET SWI_DISABLE0 NRF52 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\..\config\ant_bicycle_power_minimum_receiver_s212_pca10036;..\..\config;..\..\include;..\..\..\..\..\..\components\softdevice\s212\headers;..\..\..\..\..\bsp;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\ant;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x12000 size 0x6e000
  memory RVCT9: RAM 0x20000a00 size 0x7600
  group Application
    ../../: bicycle_power_rx.c main.c main_bicycle_power_rx.c retarget.c
  group Board Support
    ../../../../../bsp/: bsp.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_ANT
    ../../../../../../components/ant/: ant_stack_config.c
  group nRF_Drivers
    ../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/timer/: app_timer.c
software components: CMSIS:CORE 3.40.0, Device:Startup 8.0.3
