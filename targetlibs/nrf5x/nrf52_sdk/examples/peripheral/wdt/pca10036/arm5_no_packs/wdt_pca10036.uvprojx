# Keil uVision project wdt_pca10036.uvprojx, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1
  c define: BOARD_PCA10036 CONFIG_GPIO_AS_PINRESET SWI_DISABLE0 NRF52
  c misc: --c99
  c include: ..\..\config\wdt_pca10036;..\..\config;..\..;..\..\..\..\bsp;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\libraries\button;..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\device;..\..\..\..\..\components\toolchain;..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd
  asm define: BOARD_PCA10036 CONFIG_GPIO_AS_PINRESET SWI_DISABLE0 NRF52
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: main.c
  group Board Support
    ../../../../bsp/: bsp.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../components/drivers_nrf/wdt/: nrf_drv_wdt.c
  group nRF_Libraries
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c
    ../../../../../components/libraries/timer/: app_timer.c
software components: CMSIS:CORE 3.40.0, Device:Startup 8.0.3
