# Keil uVision project dfu_experimental_dual_bank_ant_pca10028_s310.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4
  c define: ANT_STACK_SUPPORT_REQD __HEAP_SIZE=0 BOARD_PCA10028 S310 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: ..\..\..\config;..\..\..;..\..\..\include;..\..\..\libs\include;..\..\..\..\..\..\components\ant\ant_stack_config;..\..\..\..\..\..\components\libraries\bootloader_dfu;..\..\..\..\..\bsp;..\..\..\..\..\..\components\softdevice\s310\headers;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\drivers_nrf\hal
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3b800 size 0x4800
  memory RVCT9: RAM 0x20002800 size 0x5800
  memory RVCT10: RAM 0x20007F80 size 0x80
  group Application
    ../../../: antfs.c antfs_ota.c bootloader.c bootloader_util_arm.c crc.c debug_pin.c dfu_dual_bank.c dfu_transport_ant.c main.c
    ../../../libs/: app_scheduler.c nrf_nvmc.c pstorage.c softdevice_handler.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_ANT
    ../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c
    ../../../../../../components/libraries/timer/: app_timer.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s310/doc/: s310_nrf51822_3.0.0_licence_agreement.txt
