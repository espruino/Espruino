# Keil uVision project dfu_experimental_dual_bank_ant_pca10028_s210.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: ANT_STACK_SUPPORT_REQD __HEAP_SIZE=0 BOARD_PCA10028 S210 NRF51 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\..\..\config;..\..\..;..\..\..\include;..\..\..\libs\include;..\..\..\..\..\..\components\ant\ant_stack_config;..\..\..\..\..\..\components\libraries\bootloader_dfu;..\..\..\..\..\bsp;..\..\..\..\..\..\components\softdevice\s210\headers;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3b800 size 0x4800
  memory RVCT9: RAM 0x20002800 size 0x5800
  group Application
    ../../../: antfs.c antfs_ota.c bootloader.c bootloader_util_arm.c crc.c debug_pin.c dfu_dual_bank.c dfu_transport_ant.c main.c
    ../../../libs/: app_scheduler.c app_timer.c nrf_delay.c nrf_nvmc.c pstorage.c softdevice_handler.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_ANT
    ../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s210/doc/: s210_nrf51422_5.0.0_licence_agreement.txt
