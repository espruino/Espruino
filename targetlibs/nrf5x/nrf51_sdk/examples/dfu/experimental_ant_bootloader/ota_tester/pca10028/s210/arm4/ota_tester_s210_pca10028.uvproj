# Keil uVision project ota_tester_s210_pca10028.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: ANT_STACK_SUPPORT_REQD S210 BOARD_PCA10028 NRF51 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\..\..\config;..\..\..\include;..\..\..\..\..\..\..\components\softdevice\s210\headers;..\..\..\..\..\..\bsp;..\..\..\..\..\..\..\components\ant\ant_stack_config;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\components\toolchain
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0xd000 size 0x33000
  memory RVCT9: RAM 0x20000900 size 0x7700
  group Application
    ../../../: ant_boot_settings_api.c main.c
  group Device
    ../../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_ANT
    ../../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
  group nRF_Drivers
    ../../../../../../../components/drivers_nrf/hal/: nrf_delay.c
  group nRF_Libraries
    ../../../../../../../components/libraries/util/: app_error.c
  group nRF_SoftDevice
    ../../../../../../../components/softdevice/s210/doc/: s210_nrf51422_5.0.0_licence_agreement.txt
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: as above
  output: s210_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: ANT_STACK_SUPPORT_REQD ANT_CONFIG_CHANNEL_USED=1>ant_stack_config ANT_CONFIG_ENC_CHANNEL_USED=0>ant_stack_config ANT_CONFIG_BURST_QUEUE_SIZE=128>ant_stack_config
  c misc: --c99
  c include: ..\..\..\config;..\..\..\include
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
