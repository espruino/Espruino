<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pca10028\dual_bank_ble_s130\iar\dfu_dual_bank_ble_s130_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\dual_bank_ble_s310\iar\dfu_dual_bank_ble_s310_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\dual_bank_ble_s110\iar\dfu_dual_bank_ble_s110_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\dual_bank_serial_s130\iar\dfu_dual_bank_serial_s130_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\dual_bank_serial_s310\iar\dfu_dual_bank_serial_s310_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\dual_bank_serial_s110\iar\dfu_dual_bank_serial_s110_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\single_bank_serial_s110\iar\dfu_single_bank_serial_s110_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\single_bank_serial_s310\iar\dfu_single_bank_serial_s310_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\single_bank_serial_s130\iar\dfu_single_bank_serial_s130_pca10028.ewp</path>
  </project>
  <batchBuild/>
</workspace>