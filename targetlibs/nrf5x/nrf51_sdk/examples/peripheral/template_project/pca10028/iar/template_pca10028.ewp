# IAR project template_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BSP_DEFINES_ONLY; BOARD_PCA10028; NRF51
  ICCARM.CCIncludePath2: ..\..; ..\..\..\..\bsp; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\device; ..\..\..\..\..\components\toolchain; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BSP_DEFINES_ONLY; BOARD_PCA10028; NRF51
  OBJCOPY.OOCOutputFile: template_pca10028.hex
  ILINK.IlinkOutputFile: template_pca10028.out
  ILINK.IlinkIcfFile: template_iar_nrf51.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Device
    ../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../components/toolchain/: system_nrf51.c
  group Application
    ../../: main.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error.c
  group Documentation
    ../../: Abstract.txt license.txt
