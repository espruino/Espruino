# IAR project gpiote_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BSP_DEFINES_ONLY; BOARD_PCA10028; NRF51
  ICCARM.CCIncludePath2: ..\..\config; ..\..; ..\..\..\..\bsp; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\drivers_nrf\timer; ..\..\..\..\..\components\drivers_nrf\ppi; ..\..\..\..\..\components\device; ..\..\..\..\..\components\toolchain; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BSP_DEFINES_ONLY; BOARD_PCA10028; NRF51
  OBJCOPY.OOCOutputFile: gpiote_pca10028.hex
  ILINK.IlinkOutputFile: gpiote_pca10028.out
  ILINK.IlinkIcfFile: gpiote_iar_nrf51.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Device
    ../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../components/toolchain/: system_nrf51.c
  group Application
    ../../: main.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c
  group nRF_Drivers
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../../../../components/drivers_nrf/timer/: nrf_drv_timer.c
  group Documentation
    ../../: Abstract.txt license.txt
