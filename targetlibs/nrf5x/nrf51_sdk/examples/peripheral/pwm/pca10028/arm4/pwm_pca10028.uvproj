# Keil uVision project pwm_pca10028.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: BOARD_PCA10028 NRF51 SWI_DISABLE0
  c misc: --c99
  c include: ..\..\config;..\..;..\..\..\..\bsp;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\components\device;..\..\..\..\..\components\toolchain;..\..\..\..\..\components\libraries\button;..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd
  asm define: BOARD_PCA10028 NRF51 SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: main.c
  group Board Support
    ../../../../bsp/: bsp.c
  group Device
    ../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../../../../components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_soc.c
  group nRF_Libraries
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c
    ../../../../../components/libraries/pwm/: app_pwm.c
    ../../../../../components/libraries/timer/: app_timer.c
