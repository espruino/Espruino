# IAR project pwm_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10028; NRF51; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\config; ..\..; ..\..\..\..\bsp; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\timer; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\libraries\pwm; ..\..\..\..\..\components\device; ..\..\..\..\..\components\toolchain; ..\..\..\..\..\components\libraries\button; ..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\ppi; ..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_PCA10028; NRF51; SWI_DISABLE0
  OBJCOPY.OOCOutputFile: pwm_pca10028.hex
  ILINK.IlinkOutputFile: pwm_pca10028.out
  ILINK.IlinkIcfFile: pwm_iar_nrf51.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c
    ../../../../../components/libraries/pwm/: app_pwm.c
    ../../../../../components/libraries/timer/: app_timer.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../../../../components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_soc.c
  group Board Support
    ../../../../bsp/: bsp.c
  group Application
    ../../: main.c
  group Device
    ../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../components/toolchain/: system_nrf51.c
