<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pca10028\s310\iar\ble_ant_app_hrm_s310_pca10028.ewp</path>
  </project>
  <batchBuild/>
</workspace>