# IAR project ble_ant_app_hrm_s310_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; ANT_STACK_SUPPORT_REQD; BOARD_PCA10028; S310; NRF51; SOFTDEVICE_PRESENT; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\bsp; ..\..\..\..\..\..\components\softdevice\s310\headers; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\..\components\ble\ble_services\ble_hrs; ..\..\..\..\..\..\components\ble\ble_services\ble_dis; ..\..\..\..\..\..\components\ble\ble_services\ble_bas; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\ant\ant_stack_config; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\ble\device_manager; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\drivers_nrf\pstorage; ..\..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\..\components\drivers_nrf\uart; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: ble_ant_app_hrm_s310_pca10028.hex
  ILINK.IlinkOutputFile: ble_ant_app_hrm_s310_pca10028.out
  ILINK.IlinkIcfFile: ble_ant_app_hrm_iar_nrf51.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/uart/: retarget.c
    ../../../../../../components/libraries/sensorsim/: sensorsim.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/uart/: app_uart.c
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_ANT
    ../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
  group Board Support
    ../../../../../bsp/: bsp.c
  group Application
    ../../../: main.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../../../components/ble/ble_services/ble_hrs/: ble_hrs.c
    ../../../../../../components/ble/device_manager/: device_manager_peripheral.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s310/doc/: s310_nrf51822_3.0.0_licence_agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
