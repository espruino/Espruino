<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pca10028\ser_s110_spi\iar\ble_dtm_s110_spi_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\ser_s110_hci\iar\ble_dtm_s110_hci_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\ser_s110_uart\iar\ble_dtm_s110_uart_pca10028.ewp</path>
  </project>
  <batchBuild/>
</workspace>