# Keil uVision project esb_prx_ack_payload_pca10028.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.2.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: BSP_DEFINES_ONLY BOARD_PCA10028 ESB_PRESENT NRF51
  c misc: --c99
  c include: ..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\bsp;..\..\..\..\..\..\..\components\properitary_rf\esb;..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\components\toolchain
  asm define: BSP_DEFINES_ONLY BOARD_PCA10028 ESB_PRESENT NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../../: main_esb_prx_ack_payload.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Properitary_RF
    ../../../../../../../components/properitary_rf/esb/arm/: esb_arm.lib
software components: CMSIS:CORE 3.40.0, Device:Startup 7.2.1
