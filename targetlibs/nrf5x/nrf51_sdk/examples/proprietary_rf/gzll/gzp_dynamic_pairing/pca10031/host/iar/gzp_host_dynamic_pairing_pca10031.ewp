# IAR project gzp_host_dynamic_pairing_pca10031.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10031; GAZELL_PRESENT; BSP_DEFINES_ONLY; NRF51
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..; ..\..\..\..\..\..\..\components\properitary_rf\gzll; ..\..\..\..\..\..\bsp; ..\..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\..\components\device; ..\..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\..\components\libraries\util; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_PCA10031; GAZELL_PRESENT; BSP_DEFINES_ONLY; NRF51
  OBJCOPY.OOCOutputFile: gzp_host_dynamic_pairing_pca10031.hex
  ILINK.IlinkOutputFile: gzp_host_dynamic_pairing_pca10031.out
  ILINK.IlinkIcfFile: gzp_iar_nrf51.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../../components/libraries/util/: nrf_assert.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../../components/drivers_nrf/hal/: nrf_delay.c nrf_ecb.c nrf_nvmc.c
  group Application
    ../../../: main_host_dynamic_pairing.c
  group nRF_Properitary_RF
    ../../../../../../../components/properitary_rf/gzll/iar/: gzll_iar.a
    ../../../../../../../components/properitary_rf/gzll/: nrf_gzp.c nrf_gzp_host.c nrf_gzp_host_nrf51.c
  group Device
    ../../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../../components/toolchain/: system_nrf51.c
