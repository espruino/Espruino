<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pca10028\iar\ant_broadcast_tx_s210_pca10028.ewp</path>
  </project>
  <batchBuild/>
</workspace>