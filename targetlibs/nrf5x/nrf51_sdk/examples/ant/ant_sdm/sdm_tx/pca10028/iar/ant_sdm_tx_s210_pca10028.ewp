# IAR project ant_sdm_tx_s210_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ANT_STACK_SUPPORT_REQD; TRACE_GPIO; TRACE_UART; S210; BOARD_PCA10028; BSP_DEFINES_ONLY; NRF51; SOFTDEVICE_PRESENT
  ICCARM.CCIncludePath2: ..\..\config; ..\..\include; ..\..\..\..\..\..\components\softdevice\s210\headers; ..\..\..\..\..\bsp; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\ant\ant_stack_config; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\hal; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: ant_sdm_tx_s210_pca10028.hex
  ILINK.IlinkOutputFile: ant_sdm_tx_s210_pca10028.out
  ILINK.IlinkIcfFile: ant_sdm_tx_iar_nrf51.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group nRF_ANT
    ../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
  group Application
    ../../: main.c retarget.c sdm_tx.c timer.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s210/doc/: s210_nrf51422_5.0.0_licence_agreement.txt
