<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pca10028\s210\iar\ant_bicycle_power_minimum_receiver_s210_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\s310\iar\ant_bicycle_power_minimum_receiver_s310_pca10028.ewp</path>
  </project>
  <batchBuild/>
</workspace>