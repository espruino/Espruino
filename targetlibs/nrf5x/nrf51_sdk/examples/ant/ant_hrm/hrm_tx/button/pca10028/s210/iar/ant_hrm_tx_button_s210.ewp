# IAR project ant_hrm_tx_button_s210.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: HEART_BEAT_MODIFICATION=0; ANT_STACK_SUPPORT_REQD; ENABLE_DEBUG_LOG_SUPPORT; TRACE_HRM_GENERAL_ENABLE; TRACE_HRM_PAGE_0_ENABLE; TRACE_HRM_PAGE_1_ENABLE; TRACE_HRM_PAGE_2_ENABLE; TRACE_HRM_PAGE_3_ENABLE; TRACE_HRM_PAGE_4_ENABLE; SWI_DISABLE0; S210; BOARD_PCA10028; NRF51; SOFTDEVICE_PRESENT
  ICCARM.CCIncludePath2: ..\..\..\..\config; ..\..\..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\..\..\components\ant\ant_state_indicator; ..\..\..\..\..\..\..\..\components\ant\ant_pulse_simulator; ..\..\..\..\..\..\..\bsp; ..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm; ..\..\..\..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\..\..\..\components\softdevice\s210\headers; ..\..\..\..\..\..\..\..\components\ant\ant_stack_config; ..\..\..\..\..\..\..\..\components\device; ..\..\..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\..\..\components\ant\ant_channel_config; ..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\pages; ..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\pages\logger; ..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\utils; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: ant_hrm_tx_button_s210.hex
  ILINK.IlinkOutputFile: ant_hrm_tx_button_s210.out
  ILINK.IlinkIcfFile: ant_hrm_tx_iar_nrf51.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../../../components/libraries/uart/: retarget.c
    ../../../../../../../../components/libraries/sensorsim/: sensorsim.c
  group Documentation
    ../../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group nRF_ANT
    ../../../../../../../../components/ant/ant_channel_config/: ant_channel_config.c
    ../../../../../../../../components/ant/ant_profiles/ant_hrm/: ant_hrm.c
    ../../../../../../../../components/ant/ant_profiles/ant_hrm/pages/: ant_hrm_page_0.c ant_hrm_page_1.c ant_hrm_page_2.c ant_hrm_page_3.c ant_hrm_page_4.c
    ../../../../../../../../components/ant/ant_pulse_simulator/: ant_pulse_simulator.c
    ../../../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
    ../../../../../../../../components/ant/ant_state_indicator/: ant_state_indicator.c
  group Board Support
    ../../../../../../../bsp/: bsp.c
  group Application
    ../../../../: main.c
  group Device
    ../../../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../../../components/toolchain/: system_nrf51.c
  group nRF_SoftDevice
    ../../../../../../../../components/softdevice/s210/doc/: s210_nrf51422_5.0.0_licence_agreement.txt
    ../../../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
