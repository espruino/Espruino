# Keil uVision project ant_hrm_tx_button_s210.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: HEART_BEAT_MODIFICATION=0 ANT_STACK_SUPPORT_REQD ENABLE_DEBUG_LOG_SUPPORT TRACE_HRM_GENERAL_ENABLE TRACE_HRM_PAGE_0_ENABLE TRACE_HRM_PAGE_1_ENABLE TRACE_HRM_PAGE_2_ENABLE TRACE_HRM_PAGE_3_ENABLE TRACE_HRM_PAGE_4_ENABLE SWI_DISABLE0 S210 BOARD_PCA10028 NRF51 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\..\..\..\config;..\..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\..\..\components\ant\ant_state_indicator;..\..\..\..\..\..\..\..\components\ant\ant_pulse_simulator;..\..\..\..\..\..\..\bsp;..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm;..\..\..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\..\..\components\softdevice\s210\headers;..\..\..\..\..\..\..\..\components\ant\ant_stack_config;..\..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\..\components\ant\ant_channel_config;..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\pages;..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\pages\logger;..\..\..\..\..\..\..\..\components\ant\ant_profiles\ant_hrm\utils
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0xd000 size 0x33000
  memory RVCT9: RAM 0x20000900 size 0x7700
  group Application
    ../../../../: main.c
  group Board Support
    ../../../../../../../bsp/: bsp.c
  group Device
    ../../../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../../: Abstract.txt license.txt
  group nRF_ANT
    ../../../../../../../../components/ant/ant_channel_config/: ant_channel_config.c
    ../../../../../../../../components/ant/ant_profiles/ant_hrm/: ant_hrm.c
    ../../../../../../../../components/ant/ant_profiles/ant_hrm/pages/: ant_hrm_page_0.c ant_hrm_page_1.c ant_hrm_page_2.c ant_hrm_page_3.c ant_hrm_page_4.c
    ../../../../../../../../components/ant/ant_pulse_simulator/: ant_pulse_simulator.c
    ../../../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
    ../../../../../../../../components/ant/ant_state_indicator/: ant_state_indicator.c
  group nRF_Drivers
    ../../../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group nRF_Libraries
    ../../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../../../components/libraries/uart/: retarget.c
    ../../../../../../../../components/libraries/sensorsim/: sensorsim.c
  group nRF_SoftDevice
    ../../../../../../../../components/softdevice/s210/doc/: s210_nrf51422_5.0.0_licence_agreement.txt
    ../../../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: as above
  output: s210_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: HEART_BEAT_MODIFICATION=0 ANT_STACK_SUPPORT_REQD ENABLE_DEBUG_LOG_SUPPORT TRACE_HRM_GENERAL_ENABLE TRACE_HRM_PAGE_0_ENABLE TRACE_HRM_PAGE_1_ENABLE TRACE_HRM_PAGE_2_ENABLE TRACE_HRM_PAGE_3_ENABLE TRACE_HRM_PAGE_4_ENABLE ANT_CONFIG_CHANNEL_USED=1>ant_stack_config ANT_CONFIG_ENC_CHANNEL_USED=0>ant_stack_config ANT_CONFIG_BURST_QUEUE_SIZE=128>ant_stack_config ANT_CONFIG_CHANNEL_USED=1>ant_stack_config ANT_CONFIG_ENC_CHANNEL_USED=0>ant_stack_config ANT_CONFIG_BURST_QUEUE_SIZE=128>ant_stack_config
  c misc: --c99
  c include: ..\..\..\..\config
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
