<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\auto\pca10028\s210\iar\ant_hrm_tx_auto_s210.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\button\pca10028\s210\iar\ant_hrm_tx_button_s210.ewp</path>
  </project>
  <batchBuild/>
</workspace>