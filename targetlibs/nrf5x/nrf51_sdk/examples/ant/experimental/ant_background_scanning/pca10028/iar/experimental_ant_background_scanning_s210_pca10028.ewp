# IAR project experimental_ant_background_scanning_s210_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ANT_STACK_SUPPORT_REQD; S210; BOARD_PCA10028; SWI_DISABLE0; NRF51; SOFTDEVICE_PRESENT
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\..\components\softdevice\s210\headers; ..\..\..\..\..\bsp; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\..\components\ant\ant_stack_config; ..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\libraries\fifo; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: experimental_ant_background_scanning_s210_pca10028.hex
  ILINK.IlinkOutputFile: experimental_ant_background_scanning_s210_pca10028.out
  ILINK.IlinkIcfFile: experimental_ant_background_scanning_iar_nrf51.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/uart/: retarget.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group nRF_ANT
    ../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
  group Board Support
    ../../../../../bsp/: bsp.c
  group Application
    ../../: main.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s210/doc/: s210_nrf51422_5.0.0_licence_agreement.txt
