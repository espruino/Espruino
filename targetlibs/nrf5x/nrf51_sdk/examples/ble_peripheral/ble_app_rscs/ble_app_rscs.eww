<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pca10028\s130\iar\ble_app_rscs_s130_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\s110\iar\ble_app_rscs_s110_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\s310\iar\ble_app_rscs_s310_pca10028.ewp</path>
  </project>
  <batchBuild/>
</workspace>