<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pca10028\s130\iar\ble_app_ancs_c_s130_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\s110\iar\ble_app_ancs_c_s110_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\ser_s110_spi\iar\ble_app_ancs_c_s110_spi_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\ser_s130_spi\iar\ble_app_ancs_c_s130_spi_pca10028.ewp</path>
  </project>
  <batchBuild/>
</workspace>