# Keil uVision project touch.uvprojx, settings and files
target touch (ARM-ADS)
  device: EFM32GG990F1024 Silicon Labs
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: touch
  AfterMake: fromelf.exe --bin --output obj\touch.bin obj\touch.axf
  c flags: Optim=4 oTime=1
  c define: EFM32GG990F1024
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32GG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..\..\..\..\..\emdrv\common\inc;..\..\..\..\..\emdrv\rtcdrv\inc;..
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32GG/Source/ARM/: startup_efm32gg.s
    ../../../../../Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group bsp
    ../../../../common/bsp/: bsp_trace.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_acmp.c em_cmu.c em_emu.c em_gpio.c em_int.c em_lesense.c em_rtc.c em_system.c em_lcd.c em_vcmp.c
  group Drivers
    ../../../../common/drivers/: vddcheck.c segmentlcd.c caplesense.c
  group emdrv
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group Source
    ../: touchdemo.c
