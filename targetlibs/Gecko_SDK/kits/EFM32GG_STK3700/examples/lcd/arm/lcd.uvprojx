# Keil uVision project lcd.uvprojx, settings and files
target lcd (ARM-ADS)
  device: EFM32GG990F1024 Silicon Labs
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: lcd
  AfterMake: fromelf.exe --bin --output obj\lcd.bin obj\lcd.axf
  c flags: Optim=4 oTime=1
  c define: EFM32GG990F1024 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32GG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32GG/Source/ARM/: startup_efm32gg.s
    ../../../../../Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group BSP
    ../../../../common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group Drivers
    ../../../../common/drivers/: rtcdrv.c vddcheck.c segmentlcd.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_lcd.c em_rtc.c em_system.c em_usart.c em_vcmp.c
  group Main
    ../: lcd.c
