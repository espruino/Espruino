<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_opt.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>ucos3</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>48000000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>1</RunSim>
        <RunTarget>0</RunTarget>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\lst\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>255</CpuCode>
      <DllOpt>
        <SimDllName>SARMCM3.DLL</SimDllName>
        <SimDllArguments>-MPU</SimDllArguments>
        <SimDlgDllName>DCM.DLL</SimDlgDllName>
        <SimDlgDllArguments>-pCM3</SimDlgDllArguments>
        <TargetDllName>SARMCM3.DLL</TargetDllName>
        <TargetDllArguments>-MPU</TargetDllArguments>
        <TargetDlgDllName>TCM.DLL</TargetDlgDllName>
        <TargetDlgDllArguments>-pCM3</TargetDlgDllArguments>
      </DllOpt>
      <DebugOpt>
        <uSim>0</uSim>
        <uTrg>1</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>1</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <nTsel>7</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>Segger\JL2CM3.dll</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>-O206 -S0 -C0 -FO7 -FD20000000 -FC8000 -FN1 -FS00 -FL0100000 -FP0($$Device:EFM32GG990F1024$Flash\EFM32GG.FLM)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGTARM</Key>
          <Name>(1010=-1,-1,-1,-1,0)(1007=-1,-1,-1,-1,0)(1008=-1,-1,-1,-1,0)(1009=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name></Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGUARM</Key>
          <Name>(106=-1,-1,-1,-1,0)(107=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>JL2CM3</Key>
          <Name>-U440000000 -O206 -S0 -A0 -C0 -JU1 -JI127.0.0.1 -JP0 -RST0 -N00("ARM CoreSight SW-DP") -D00(2BA01477) -L00(0) -TO18 -TC10000000 -TP21 -TDS8007 -TDT0 -TDC1F -TIEFFFFFFFF -TIP8 -TB1 -TFE0 -FO7 -FD20000000 -FC8000 -FN1 -FS00 -FL0100000 -FP0($$Device:EFM32GG990F1024$Flash\EFM32GG.FLM)</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <DebugFlag>
        <trace>0</trace>
        <periodic>0</periodic>
        <aLwin>1</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
    </TargetOption>
  </Target>
  
        <Group>
          <GroupName>APP</GroupName>
          <Files>
            <File>
              <FileName>app.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\src\app\app.c</FilePath>
            </File>
            <File>
              <FileName>app_hooks.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\src\app\app_hooks.c</FilePath>
            </File>
            <File>
              <FileName>app_task_one.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\src\app\app_task_one.c</FilePath>
            </File>
            <File>
              <FileName>app_task_two.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\src\app\app_task_two.c</FilePath>
            </File>
            <File>
              <FileName>app_task_three.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\src\app\app_task_three.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>BSP</GroupName>
          <Files>
            <File>
              <FileName>bspos.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\src\bsp\bspos.c</FilePath>
            </File>
            <File>
              <FileName>bsp_bcc.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\common\bsp\bsp_bcc.c</FilePath>
            </File>
            <File>
              <FileName>bsp_stk.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\common\bsp\bsp_stk.c</FilePath>
            </File>
            <File>
              <FileName>bsp_stk_leds.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\common\bsp\bsp_stk_leds.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>CMSIS</GroupName>
          <Files>
            <File>
              <FileName>system_efm32gg.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\Device\SiliconLabs\EFM32GG\Source\system_efm32gg.c</FilePath>
            </File>
            <File>
              <FileName>startup_efm32gg.s</FileName>
              <FileType>2</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\startup\EFM32GG\arm\startup_efm32gg.s</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>Drivers</GroupName>
          <Files>
            <File>
              <FileName>retargetio.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\common\drivers\retargetio.c</FilePath>
            </File>
            <File>
              <FileName>retargetserial.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\common\drivers\retargetserial.c</FilePath>
            </File>
            <File>
              <FileName>segmentlcd.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\common\drivers\segmentlcd.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>emlib</GroupName>
          <Files>
            <File>
              <FileName>em_cmu.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\emlib\src\em_cmu.c</FilePath>
            </File>
            <File>
              <FileName>em_ebi.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\emlib\src\em_ebi.c</FilePath>
            </File>
            <File>
              <FileName>em_emu.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\emlib\src\em_emu.c</FilePath>
            </File>
            <File>
              <FileName>em_gpio.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\emlib\src\em_gpio.c</FilePath>
            </File>
            <File>
              <FileName>em_lcd.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\emlib\src\em_lcd.c</FilePath>
            </File>
            <File>
              <FileName>em_system.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\emlib\src\em_system.c</FilePath>
            </File>
            <File>
              <FileName>em_usart.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\emlib\src\em_usart.c</FilePath>
            </File>
            <File>
              <FileName>em_leuart.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\emlib\src\em_leuart.c</FilePath>
            </File>
            <File>
              <FileName>em_int.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\emlib\src\em_int.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>uC/CPU</GroupName>
          <Files>
            <File>
              <FileName>cpu_core.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uC-CPU\cpu_core.c</FilePath>
            </File>
            <File>
              <FileName>cpu_c.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uC-CPU\ARM-Cortex-M3\RealView\cpu_c.c</FilePath>
            </File>
            <File>
              <FileName>cpu_a.asm</FileName>
              <FileType>2</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uC-CPU\ARM-Cortex-M3\RealView\cpu_a.asm</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>uC/OS-III</GroupName>
          <Files>
            <File>
              <FileName>os_cfg_app.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Source\os_cfg_app.c</FilePath>
            </File>
            <File>
              <FileName>os_core.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Source\os_core.c</FilePath>
            </File>
            <File>
              <FileName>os_dbg.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Source\os_dbg.c</FilePath>
            </File>
            <File>
              <FileName>os_flag.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Source\os_flag.c</FilePath>
            </File>
            <File>
              <FileName>os_int.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Source\os_int.c</FilePath>
            </File>
            <File>
              <FileName>os_mem.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Source\os_mem.c</FilePath>
            </File>
            <File>
              <FileName>os_msg.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Source\os_msg.c</FilePath>
            </File>
            <File>
              <FileName>os_mutex.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Source\os_mutex.c</FilePath>
            </File>
            <File>
              <FileName>os_pend_multi.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Source\os_pend_multi.c</FilePath>
            </File>
            <File>
              <FileName>os_prio.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Source\os_prio.c</FilePath>
            </File>
            <File>
              <FileName>os_q.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Source\os_q.c</FilePath>
            </File>
            <File>
              <FileName>os_sem.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Source\os_sem.c</FilePath>
            </File>
            <File>
              <FileName>os_stat.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Source\os_stat.c</FilePath>
            </File>
            <File>
              <FileName>os_task.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Source\os_task.c</FilePath>
            </File>
            <File>
              <FileName>os_tick.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Source\os_tick.c</FilePath>
            </File>
            <File>
              <FileName>os_time.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Source\os_time.c</FilePath>
            </File>
            <File>
              <FileName>os_tmr.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Source\os_tmr.c</FilePath>
            </File>
            <File>
              <FileName>os_var.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Source\os_var.c</FilePath>
            </File>
            <File>
              <FileName>os_cpu_c.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView\os_cpu_c.c</FilePath>
            </File>
            <File>
              <FileName>os_cpu_a.s</FileName>
              <FileType>2</FileType>
              <FilePath>..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView\os_cpu_a.s</FilePath>
            </File>
          </Files>
        </Group>

</ProjectOpt>
